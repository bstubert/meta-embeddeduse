# Enable fontconfig to get system freetype fonts
PACKAGECONFIG_FONTS += "fontconfig"

