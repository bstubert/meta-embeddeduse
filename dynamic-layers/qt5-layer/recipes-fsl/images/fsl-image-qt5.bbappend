DESCRIPTION = "Extension of Freescale Image: Single Qt5 app started by Weston"
LICENSE = "MIT"


IMAGE_INSTALL += " \
    cuteradio \
    wayland-cuteradio \
"

